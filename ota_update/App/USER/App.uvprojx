# Keil uVision project App.uvprojx, settings and files
target App_A (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08010000,0x00030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: App_A +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -DGD32F40X -DAPP_ADDR=0x08010000
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\..\common
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c gd32f4xx_it.c system_gd32f4xx.c
  group CORE
    ../CORE/: startup_gd32f407.s
  group FWLIB
    ../FWLIB/src/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_fmc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group OTA
    ../../common/: ota_flash.c ota_crc.c bootmgr.c ota_log.c
target App_B (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08040000,0x00030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: App_B +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -DGD32F40X -DAPP_ADDR=0x08040000
  c include: as above
  memory RVCT4: ROM 0x8040000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
